# Repository Aquesnail/3PhaseInverter

File README.md:

# 3PhaseInverter

三相逆变器项目：**硬件（KiCad + 立创EDA）+ 软件（STM32G474 固件）+ CubeMX 配置 + Simulink 仿真**放在同一个仓库里，保证引脚改动、符号重生成和固件改动能一次性提交、一起回退。

## 目录结构

```
3PhaseInverter/
├── Hardware/
│   ├── G474VC_Core/                 # KiCad 工程（STM32G474VCTx 核心板，出板以此为准）
│   │   ├── G474VC_Core.kicad_pro    # 工程文件
│   │   ├── G474VC_Core.kicad_sch    # 根图纸（连接器 / 采样口 / 复位）
│   │   ├── G474_MCU.kicad_sch       # MCU 页（U2 + 9 组差分采样 + 晶振 + 电源）
│   │   ├── Power.kicad_sch          # 电源页（12V→5V 降压 SY8368QNC、LDO）
│   │   ├── CAN.kicad_sch            # CAN 收发页
│   │   ├── DebugerPower.kicad_sch   # 调试供电页
│   │   ├── *.kicad_sch              # 其它子图纸（PWM/ADC 引出等）
│   │   ├── G474VC_Core.kicad_pcb    # PCB
│   │   └── libs/                    # 工程自带符号库 / 封装库 / 3D 模型
│   │       ├── project/             # 由 CubeMX 配置生成的 STM32 符号
│   │       └── lcsc/                # LCSC 导入的符号与封装
│   └── 逆变器.eprj2                 # 立创EDA专业版工程（含完整立创商城物料/封装，供采购与下单）
├── Simulink/
│   ├── DroopControl.slx             # 下垂控制模型
│   ├── OnlyCurrent.slx              # 电流环模型
│   └── THD.m                        # 总谐波畸变分析脚本
└── Software/
    ├── G474_Software.ioc            # STM32CubeMX 工程（引脚/时钟/外设配置的唯一源头）
    ├── ioc2kicad.py                 # 从 .ioc 生成 KiCad 符号 + 引脚表
    └── kicad/                       # 生成物：引脚表、报告、预览
```

## 引脚/符号的更新流程

`.ioc` 是引脚配置的**唯一权威**（software 和 hardware 共用）：

1. 在 STM32CubeMX 里修改 `Software/G474_Software.ioc`；
2. 运行 `Hardware/G474VC_Core/update_symbol_from_ioc.bat`（内部调用 `Software/ioc2kicad.py`），
   重新生成 `Hardware/G474VC_Core/libs/project/3phase_inverter.kicad_sym`；
3. 原理图里更新 U2 符号，同步改接线；
4. 固件按新引脚表调整；
5. **上述改动放在同一次提交里**，回退时不会出现"符号和 .ioc 不一致"的状态。

## 硬件要点

- MCU：STM32G474VCTx（LQFP100）
- 9 组差分 ADC 输入，分成 3 个 PH2.0x6 接口，每组 = ADC1 + ADC2 + ADC3 各一对（可三相同步采样）
- 每个差分对中 **通道号小的一侧为 `+`**
- PWM：HRTIM1 CHA / CHE / CHF 三对互补输出
- 通信：FDCAN1（经 TCAN1044 收发器）、USART2、SWD
- 电源：12V → 5V（SY8368QNC 同步降压）→ 3.3V（TPS74801）/ 3.3V 模拟（LP5907）

## 仿真（Simulink）

| 文件 | 说明 |
|---|---|
| `Simulink/OnlyCurrent.slx` | 电流环（内环）模型 |
| `Simulink/DroopControl.slx` | 下垂控制（外环）模型 |
| `Simulink/THD.m` | 输出波形 THD 分析脚本 |

## 立创EDA 工程

`Hardware/逆变器.eprj2` 是立创EDA专业版工程（SQLite 单文件），用于**采购/下单/物料核对**；
PCB 出板仍以 `Hardware/G474VC_Core/G474VC_Core.kicad_pcb` 为准，两边改动请保持同步并一起提交。

## 备注

- KiCad 10 自带 Git 集成（工程管理器里 Version Control → Commit / Push / Pull），
  本仓库根目录即仓库根，KiCad 会自动向上发现 `.git`；但它的提交是**整仓库**范围的，
  日常建议用命令行 / VS Code 按路径提交，避免把固件半成品一起提交。
- `.history/` 是 KiCad 自己的本地历史仓库，已在 `.gitignore` 中排除。

## KiCad design Hardware/G474VC_Core/G474VC_Core.kicad_pcb

Parts:
C2, C19, C47, C48, C86: 1uF; C_0603
C97, C100: 4.7uF; C_0603
D2: 12V TVS; D_SMB
D3, D4, D5, D6, D7, D8: PESD3V3S1UL; D_SOD-882
D10: Zener 12V; D_SOD-123F
D14, D15, D16, D17, D18: 5V TVS; D_SOD-123F
D23: D_Schottky; D_SOD-123F
J1: GH1.25x4; JST_GH_BM04B-GHS-TBT_1x04-1MP_P1.25mm_Vertical
J2: PH2.0x8; JST_PH_B8B-PH-K_1x08_P2.00mm_Vertical
J4, J13, J14, J15, J16: PH2.0x2; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J5: GH1.25x2; JST_GH_BM02B-GHS-TBT_1x02-1MP_P1.25mm_Vertical
J6: GH1.25x6; JST_GH_BM06B-GHS-TBT_1x06-1MP_P1.25mm_Vertical
L15: 4.7uH; L_Changjiang_FXL0420
Q2: PMOS; C2927416_DFN-8_L5_9-W5_2-P1_27-LS6_2-BL; LCSC C2927416
R5, R6, R12, R13: 22R; R_0402_NoSilk
R8, R16, R17, R18, R19: 10K; R_0402_NoSilk
R20: 10K; R_0603
RN1: 0402x4; C2002_RES-ARRAY-SMD_0402-8P-L2_0-W1_0-BL; LCSC C2002
RN2: 0402x4 22R; C2002_RES-ARRAY-SMD_0402-8P-L2_0-W1_0-BL; LCSC C2002
SW2, SW3, SW4, SW5: SW_Push; SW_SPST_PTS810
TP1, TP2: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm

Connections:
+3.3V: R16.2, R17.2, R18.2, R19.2; also elsewhere on the board
+5V: C100.2, D14.1 (A1), D15.1 (A1), D16.1 (A1), D17.1 (A1), D18.1 (A1), J1.2, J2.1, J13.1, J14.1, J15.1, J16.1, L15.2; also elsewhere on the board
+5VA: C97.2, L15.1; also elsewhere on the board
+12V: Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D); also elsewhere on the board
/CAN/CANH: J5.1; also elsewhere on the board
/CAN/CANL: J5.2; also elsewhere on the board
/Debuger_5V: J6.6; also elsewhere on the board
/G474_MCU/BOOT: R8.1; also elsewhere on the board
/G474_MCU/BT1: C48.1, R19.1, SW5.2; also elsewhere on the board
/G474_MCU/BT2: C47.1, R18.1, SW4.2; also elsewhere on the board
/G474_MCU/BT3: C19.1, R17.1, SW3.2; also elsewhere on the board
/G474_MCU/DAC_11: TP1.1 (1_1); also elsewhere on the board
/G474_MCU/DAC_12: TP2.1 (1_1); also elsewhere on the board
/G474_MCU/GPIO_OUT1: J2.3; also elsewhere on the board
/G474_MCU/GPIO_OUT2: J2.4; also elsewhere on the board
/G474_MCU/GPIO_OUT3: J2.5; also elsewhere on the board
/G474_MCU/GPIO_OUT4: J2.6; also elsewhere on the board
/G474_MCU/GPIO_OUT5: J2.7; also elsewhere on the board
/G474_MCU/GPIO_OUT6: J2.8; also elsewhere on the board
/G474_MCU/NRST: C2.1, R16.1, SW2.2; also elsewhere on the board
/G474_MCU/PWM1N: RN2.8; also elsewhere on the board
/G474_MCU/PWM1P: RN2.7; also elsewhere on the board
/G474_MCU/PWM2N: RN2.6; also elsewhere on the board
/G474_MCU/PWM2P: RN2.5; also elsewhere on the board
/G474_MCU/PWM3N: R5.1; also elsewhere on the board
/G474_MCU/PWM3P: R6.1; also elsewhere on the board
/G474_MCU/SWCLK: RN1.6; also elsewhere on the board
/G474_MCU/SWDIO: RN1.5; also elsewhere on the board
/G474_MCU/USART2_RX: R12.1; also elsewhere on the board
/G474_MCU/USART2_TX: R13.1; also elsewhere on the board
/G474_MCU/USART3_RX: RN1.8; also elsewhere on the board
/G474_MCU/USART3_TX: RN1.7; also elsewhere on the board
/PWM_Out/PWM1N: RN2.2; also elsewhere on the board
/PWM_Out/PWM1P: RN2.1; also elsewhere on the board
/PWM_Out/PWM2N: RN2.4; also elsewhere on the board
/PWM_Out/PWM2P: RN2.3; also elsewhere on the board
/PWM_Out/PWM3N: R6.2; also elsewhere on the board
/PWM_Out/PWM3P: R5.2; also elsewhere on the board
GND: C2.2, C19.2, C47.2, C48.2, C97.1, C100.1, D2.2 (A2), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D14.2 (A2), D15.2 (A2), D16.2 (A2), D17.2 (A2), D18.2 (A2), J1.1, J2.2, J4.2, J6.5, J13.2, J14.2, J15.2, J16.2, R8.2, R20.2, SW2.1, SW3.1, SW4.1, SW5.1; also elsewhere on the board
unnamed: D3.1 (K), J6.1, RN1.1
unnamed: D4.1 (K), J6.2, RN1.2
unnamed: D5.1 (K), J6.3, RN1.3
unnamed: D6.1 (K), J6.4, RN1.4
unnamed: D7.1 (K), J1.4, R13.2
unnamed: D8.1 (K), J1.3, R12.2
unnamed: C86.1, D10.2 (A), D23.2 (A), Q2.4 (G), R20.1
unnamed: C86.2, D2.1 (A1), D10.1 (K), D23.1 (K), J4.1, Q2.1 (S), Q2.2 (S), Q2.3 (S)

Parts:
J19: Conn_01x10; JST_PH_B10B-PH-K_1x10_P2.00mm_Vertical

Connections:
+5V: J19.10; also elsewhere on the board
/PWM_Out/PWM1N: J19.2; also elsewhere on the board
/PWM_Out/PWM1P: J19.1; also elsewhere on the board
/PWM_Out/PWM2N: J19.5; also elsewhere on the board
/PWM_Out/PWM2P: J19.4; also elsewhere on the board
/PWM_Out/PWM3N: J19.8; also elsewhere on the board
/PWM_Out/PWM3P: J19.7; also elsewhere on the board
GND: J19.3, J19.6, J19.9; also elsewhere on the board

Parts:
C105, C106, C123, C126: 10nF; C_0402_NoSilk
J27: Conn_01x10; JST_PH_B10B-PH-K_1x10_P2.00mm_Vertical

Connections:
+3.3VA: J27.9; also elsewhere on the board
+5VA: J27.8; also elsewhere on the board
/ADC_Out23/IN1+: C126.2, J27.2; also elsewhere on the board
/ADC_Out23/IN1-: C105.2, J27.3; also elsewhere on the board
/ADC_Out23/IN2+: C106.2, J27.5; also elsewhere on the board
/ADC_Out23/IN2-: C123.2, J27.6; also elsewhere on the board
GND: C105.1, C106.1, C123.1, C126.1, J27.1, J27.4, J27.7, J27.10; also elsewhere on the board

Notes on the sheet:
小电容放在引脚处吸收线束上的共模噪声

Parts:
C15: 1uF; C_0603
R7: 10K; R_0402_NoSilk
U9: LM66100DCK; SOT-363_SC-70-6

Connections:
+5V: C15.1, R7.1, U9.3 (~CE), U9.6 (VOUT); also elsewhere on the board
/Debuger_5V: U9.1 (VIN); also elsewhere on the board
GND: C15.2, U9.2 (GND); also elsewhere on the board
unnamed: R7.2, U9.5 (ST)

Parts:
C18: 100nF; C_0402_NoSilk
C20, C21, C22, C23, C24, C33, C45: 1uF; C_0402_NoSilk
C25, C26, C27, C28, C29, C30, C46, C51, C54, C57, C60, C65, C68, C71: 22nF; C_0402_NoSilk
C31, C32, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C49, C50, C52, C53, C55, C56, C58, C59, C61, C62, C66, C67, C69, C70, C72, C73: 2.2nF; C_0402_NoSilk
C63, C64: 20pF; C_0402_NoSilk
C83, C108, C115, C116: 47nF; C_0402_NoSilk
R14: 50R; C_0402_NoSilk
R27, R28, R29, R30: 50R; R_0402_NoSilk
U2: STM32G474VCTx_Software; LQFP-100_14x14mm_P0.5mm
Y1: 24Mhz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C20.1, C21.1, C22.1, C23.1, C24.1, C45.1, U2.6 (VBAT), U2.24 (VDD), U2.49 (VDD), U2.64 (VDD), U2.75 (VDD), U2.100 (VDD); also elsewhere on the board
+3.3VA: C33.1, R14.2, U2.37 (VDDA); also elsewhere on the board
/ADC_Out1/IN1+: C28.1, C34.2, U2.20 (PA0-ADC1_IN1); also elsewhere on the board
/ADC_Out1/IN1-: C28.2, C35.2, U2.21 (PA1-ADC1_IN2); also elsewhere on the board
/ADC_Out1/IN2+: C29.1, C42.2, U2.28 (PA6-ADC2_IN3); also elsewhere on the board
/ADC_Out1/IN2-: C29.2, C43.2, U2.29 (PA7-ADC2_IN4); also elsewhere on the board
/ADC_Out1/IN3+: C30.1, C32.2, U2.33 (PB1-ADC3_IN1); also elsewhere on the board
/ADC_Out1/IN3-: C30.2, C31.2, U2.40 (PE9-ADC3_IN2); also elsewhere on the board
/ADC_Out2/IN1+: C46.1, C49.2, U2.22 (PA2-ADC1_IN3); also elsewhere on the board
/ADC_Out2/IN1-: C46.2, C50.2, U2.25 (PA3-ADC1_IN4); also elsewhere on the board
/ADC_Out2/IN2+: C51.1, C52.2, U2.31 (PC5-ADC2_IN11); also elsewhere on the board
/ADC_Out2/IN2-: C51.2, C53.2, U2.34 (PB2-ADC2_IN12); also elsewhere on the board
/ADC_Out2/IN3+: C54.1, C55.2, U2.44 (PE13-ADC3_IN3); also elsewhere on the board
/ADC_Out2/IN3-: C54.2, C56.2, U2.38 (PE7-ADC3_IN4); also elsewhere on the board
/ADC_Out3/IN1+: C71.1, C72.2, U2.45 (PE14-ADC4_IN1); also elsewhere on the board
/ADC_Out3/IN1-: C71.2, C73.2, U2.46 (PE15-ADC4_IN2); also elsewhere on the board
/ADC_Out3/IN2+: C57.1, C58.2, U2.51 (PB12-ADC4_IN3); also elsewhere on the board
/ADC_Out3/IN2-: C57.2, C59.2, U2.53 (PB14-ADC4_IN4); also elsewhere on the board
/ADC_Out3/IN3+: C60.1, C61.2, U2.55 (PD8-ADC5_IN12); also elsewhere on the board
/ADC_Out3/IN3-: C60.2, C62.2, U2.56 (PD9-ADC5_IN13); also elsewhere on the board
/ADC_Out23/IN1+: C68.1, C69.2, U2.57 (PD10-ADC4_IN7); also elsewhere on the board
/ADC_Out23/IN1-: C68.2, C70.2, U2.58 (PD11-ADC4_IN8); also elsewhere on the board
/ADC_Out23/IN2+: C65.1, C66.2, U2.59 (PD12-ADC5_IN9); also elsewhere on the board
/ADC_Out23/IN2-: C65.2, C67.2, U2.60 (PD13-ADC5_IN10); also elsewhere on the board
/ADC_Out/IN1+: C26.1, C40.2, U2.15 (PC0-ADC1_IN6); also elsewhere on the board
/ADC_Out/IN1-: C26.2, C41.2, U2.16 (PC1-ADC1_IN7); also elsewhere on the board
/ADC_Out/IN2+: C27.1, C36.2, U2.17 (PC2-ADC2_IN8); also elsewhere on the board
/ADC_Out/IN2-: C27.2, C37.2, U2.18 (PC3-ADC2_IN9); also elsewhere on the board
/ADC_Out/IN3+: C25.1, C38.2, U2.41 (PE10-ADC3_IN14); also elsewhere on the board
/ADC_Out/IN3-: C25.2, C39.2, U2.42 (PE11-ADC3_IN15); also elsewhere on the board
/CAN/CAN_RX: U2.72 (PA11-FDCAN1_RX); also elsewhere on the board
/CAN/CAN_STB: U2.71 (PA10-GPIO_Output); also elsewhere on the board
/CAN/CAN_TX: U2.73 (PA12-FDCAN1_TX); also elsewhere on the board
/G474_MCU/ADC_SIG_ENDED1: C116.2, R30.2, U2.54 (PB15)
/G474_MCU/ADC_SIG_ENDED2: C115.2, R29.1, U2.52 (PB13)
/G474_MCU/ADC_SIG_ENDED3: C108.2, R28.1, U2.61 (PD14)
/G474_MCU/ADC_SIG_ENDED4: C83.2, R27.1, U2.43 (PE12)
/G474_MCU/ADC_SIG_ENDED 1: R30.1; also elsewhere on the board
/G474_MCU/ADC_SIG_ENDED 2: R29.2; also elsewhere on the board
/G474_MCU/ADC_SIG_ENDED 3: R28.2; also elsewhere on the board
/G474_MCU/ADC_SIG_ENDED 4: R27.2; also elsewhere on the board
/G474_MCU/BOOT: U2.95 (PB8); also elsewhere on the board
/G474_MCU/BT1: U2.2 (PE3-GPIO_Output); also elsewhere on the board
/G474_MCU/BT2: U2.1 (PE2-GPIO_Output); also elsewhere on the board
/G474_MCU/BT3: U2.4 (PE5-GPIO_Output); also elsewhere on the board
/G474_MCU/DAC_11: U2.26 (PA4-COMP_DAC11_group); also elsewhere on the board
/G474_MCU/DAC_12: U2.27 (PA5-COMP_DAC12_group); also elsewhere on the board
/G474_MCU/ENCODERA: U2.85 (PD3-S_TIM2_CH1)
/G474_MCU/ENCODERB: U2.86 (PD4-S_TIM2_CH2)
/G474_MCU/GPIO_OUT1: U2.89 (PD7-GPIO_Output); also elsewhere on the board
/G474_MCU/GPIO_OUT2: U2.90 (PB3-GPIO_Output); also elsewhere on the board
/G474_MCU/GPIO_OUT3: U2.91 (PB4-GPIO_Output); also elsewhere on the board
/G474_MCU/GPIO_OUT4: U2.92 (PB5-GPIO_Output); also elsewhere on the board
/G474_MCU/GPIO_OUT5: U2.93 (PB6-GPIO_Output); also elsewhere on the board
/G474_MCU/GPIO_OUT6: U2.94 (PB7-GPIO_Output); also elsewhere on the board
/G474_MCU/I2C1_SCL: U2.78 (PA15-I2C1_SCL); also elsewhere on the board
/G474_MCU/I2C1_SDA: U2.96 (PB9-I2C1_SDA); also elsewhere on the board
/G474_MCU/NRST: U2.14 (PG10); also elsewhere on the board
/G474_MCU/OLED_RES: U2.3 (PE4-GPIO_Output); also elsewhere on the board
/G474_MCU/PWM1N: U2.70 (PA9-HRTIM1_CHA2); also elsewhere on the board
/G474_MCU/PWM1P: U2.69 (PA8-HRTIM1_CHA1); also elsewhere on the board
/G474_MCU/PWM2N: U2.68 (PC9-HRTIM1_CHE2); also elsewhere on the board
/G474_MCU/PWM2P: U2.67 (PC8-HRTIM1_CHE1); also elsewhere on the board
/G474_MCU/PWM3N: U2.66 (PC7-HRTIM1_CHF2); also elsewhere on the board
/G474_MCU/PWM3P: U2.65 (PC6-HRTIM1_CHF1); also elsewhere on the board
/G474_MCU/SWCLK: U2.77 (PA14-SYS_JTCK-SWCLK); also elsewhere on the board
/G474_MCU/SWDIO: U2.76 (PA13-SYS_JTMS-SWDIO); also elsewhere on the board
/G474_MCU/USART2_RX: U2.88 (PD6-USART2_RX); also elsewhere on the board
/G474_MCU/USART2_TX: U2.87 (PD5-USART2_TX); also elsewhere on the board
/G474_MCU/USART3_RX: U2.80 (PC11-USART3_RX); also elsewhere on the board
/G474_MCU/USART3_TX: U2.79 (PC10-USART3_TX); also elsewhere on the board
/G474_MCU/XTAL_IN: C63.2, U2.12 (PF0-OSC_IN-RCC_OSC_IN), Y1.1
/G474_MCU/XTAL_OUT: C64.2, U2.13 (PF1-OSC_OUT-RCC_OSC_OUT), Y1.3
GND: C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C31.1, C32.1, C33.2, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C45.2, C49.1, C50.1, C52.1, C53.1, C55.1, C56.1, C58.1, C59.1, C61.1, C62.1, C63.1, C64.1, C66.1, C67.1, C69.1, C70.1, C72.1, C73.1, C83.1, C108.1, C115.1, C116.1, U2.23 (VSS), U2.35 (VSSA), U2.48 (VSS), U2.63 (VSS), U2.74 (VSS), U2.99 (VSS), Y1.2 (G), Y1.4 (G); also elsewhere on the board
unnamed: C18.1, R14.1, U2.36 (VREF+)

Notes on the sheet:
68Khz

Parts:
RF2: DL-MMCX-KE-180; C2894792_MMCX-TH_DL-MMCX-KE-180; LCSC C2894792

Connections:
/G474_MCU/ADC_SIG_ENDED 1: RF2.1 (SIG); also elsewhere on the board
GND: RF2.2 (GND), RF2.3 (GND), RF2.4 (GND), RF2.5 (GND); also elsewhere on the board

Parts of its further copies:
RF3, RF4, RF5: DL-MMCX-KE-180; C2894792_MMCX-TH_DL-MMCX-KE-180; LCSC C2894792

Connections of its further copies:
/G474_MCU/ADC_SIG_ENDED 2: RF3.1 (SIG); also elsewhere on the board
/G474_MCU/ADC_SIG_ENDED 3: RF4.1 (SIG); also elsewhere on the board
/G474_MCU/ADC_SIG_ENDED 4: RF5.1 (SIG); also elsewhere on the board
GND: RF3.2 (GND), RF3.3 (GND), RF3.4 (GND), RF3.5 (GND), RF4.2 (GND), RF4.3 (GND), RF4.4 (GND), RF4.5 (GND), RF5.2 (GND), RF5.3 (GND), RF5.4 (GND), RF5.5 (GND); also elsewhere on the board

Parts:
C7: 560pf; C_0402_NoSilk
C8, C9, C10, C11, C87, C96: 4.7uF; C_0603
C74: 2.2uF; C_0402_NoSilk
C75, C76, C77, C78, C79: 22uF; C_1206
C80: 220pF; C_0402_NoSilk
C81: 100nF; C_0402_NoSilk
C82, C85, C88, C94: 10uF; C_1206
C92: 1uF; C_0402_NoSilk
C130, C131: 100nf; C_0402_NoSilk
D9, D11, D12, D13, D19: LED; LED_0603_1608Metric
L1: 3.3uH; L_APV_APH0420
L12: 600R 100Mhz; L_0805_2012Metric
R3: 1.15K; R_0402_NoSilk
R4: 3.75K; R_0402_NoSilk
R21: 140K; R_0402_NoSilk
R22: 10K; R_0402_NoSilk
R23: 100K; R_0402_NoSilk
R24: 13.7K; R_0402_NoSilk
R25: 1K; R_0402_NoSilk
R31, R33, R34, R35: 5K; R_0603
R32: 10K; R_0603
U1: SY8368QNC; C125897_QFN-10_L3_0-W3_0-P0_45-TL_SILERGY; LCSC C125897
U3: LP5907MFX-3.3; SOT-23-5
U4: TPS74801DRC; VSON-10-1EP_3x3mm_P0.5mm_EP1.65x2.4mm_ThermalVias

Connections:
+3.3V: C9.2, C11.2, D19.2 (A), R4.1, U4.9 (OUT), U4.10 (OUT); also elsewhere on the board
+3.3VA: C10.2, D13.2 (A), U3.5 (OUT); also elsewhere on the board
+5V: C8.2, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, D12.2 (A), L1.2, R23.1, U4.1 (IN), U4.2 (IN), U4.4 (BIAS), U4.5 (EN); also elsewhere on the board
+5VA: C87.2, D9.2 (A), L12.1; also elsewhere on the board
+12V: C82.1, C85.1, C88.1, C94.1, C130.1, C131.1, D11.2 (A), R21.1, U1.7 (IN), U1.8 (IN); also elsewhere on the board
/MainPower/FB: R23.2, R24.1, R25.2, U1.4 (FB)
/MainPower/LX: C81.2, L1.1, U1.10 (LX)
GND: C7.2, C8.1, C9.1, C10.1, C11.1, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C82.2, C85.2, C87.1, C88.2, C92.2, C94.2, C96.1, C130.2, C131.2, R3.2, R22.2, R24.2, R31.1, R32.1, R33.1, R34.1, R35.1, U1.3 (ILMT), U1.9 (GND), U3.2 (GND), U4.6 (GND), U4.11 (GND); also elsewhere on the board
unnamed: C80.2, R25.1
unnamed: D9.1 (K), R31.2
unnamed: D11.1 (K), R32.2
unnamed: D12.1 (K), R33.2
unnamed: D13.1 (K), R35.2
unnamed: D19.1 (K), R34.2
unnamed: C81.1, U1.6 (BS)
unnamed: C92.1, R21.2, R22.1, U1.1 (EN)
unnamed: C74.1, U1.5 (VC)
unnamed: C96.2, L12.2, U3.1 (IN), U3.3 (EN)
unnamed: R3.1, R4.2, U4.8 (FB)
unnamed: C7.1, U4.7 (SS)

Parts:
C16: 100nF; C_0402_NoSilk
C44: 4.7nF; C_0402_NoSilk
D1: ESDCAN24-2BLY_C5158050; C5158050_SOT-23-3_L2_9-W1_3-P1_90-LS2_4-BR; LCSC C5158050
R10, R11: 62R; R_0402_NoSilk
U10: TCAN1044AVDRBRQ1; C3234119_TDFN-8_L3_0-W3_0-P0_65-BL-EP; LCSC C3234119

Connections:
+5V: C16.1, U10.3 (VCC), U10.5 (NC/VIO); also elsewhere on the board
/CAN/CANH: D1.1, R10.1, U10.7 (CANH); also elsewhere on the board
/CAN/CANL: D1.2, R11.2, U10.6 (CANL); also elsewhere on the board
/CAN/CAN_RX: U10.4 (RXD); also elsewhere on the board
/CAN/CAN_STB: U10.8 (STB); also elsewhere on the board
/CAN/CAN_TX: U10.1 (TXD); also elsewhere on the board
GND: C16.2, C44.1, D1.3, U10.2 (GND), U10.9 (Pad); also elsewhere on the board
unnamed: C44.2, R10.2, R11.1

Schematic: ADC_Out.kicad_sch

Parts:
C1: 100nF; C_0603
C13, C14, C17, C84, C109, C120: 10nF; C_0402_NoSilk
J3: Conn_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J10: Conn_01x10; JST_PH_B10B-PH-K_1x10_P2.00mm_Vertical
R1: 50R; R_0603

Connections:
+3.3VA: R1.2; also elsewhere on the board
+5VA: J3.1; also elsewhere on the board
/ADC_Out1/IN1+: C13.2, J10.2; also elsewhere on the board
/ADC_Out1/IN1-: C14.2, J10.3; also elsewhere on the board
/ADC_Out1/IN2+: C84.2, J10.5; also elsewhere on the board
/ADC_Out1/IN2-: C109.2, J10.6; also elsewhere on the board
/ADC_Out1/IN3+: C17.2, J10.8; also elsewhere on the board
/ADC_Out1/IN3-: C120.2, J10.9; also elsewhere on the board
GND: C1.2, C13.1, C14.1, C17.1, C84.1, C109.1, C120.1, J3.2, J3.4, J10.1, J10.4, J10.7, J10.10; also elsewhere on the board
unnamed: C1.1, J3.3, R1.1

Parts of its further copies:
C3, C4, C5, C89, C90, C91, C93, C99, C102, C103, C104, C107, C110, C117, C119, C121, C122, C125: 10nF; C_0402_NoSilk
C6, C12, C101: 100nF; C_0603
J7, J8, J9: Conn_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J11, J12, J21: Conn_01x10; JST_PH_B10B-PH-K_1x10_P2.00mm_Vertical
R2, R9, R15: 50R; R_0603

Connections of its further copies:
+3.3VA: R2.2, R9.2, R15.2; also elsewhere on the board
+5VA: J7.1, J8.1, J9.1; also elsewhere on the board
/ADC_Out2/IN1+: C89.2, J11.2; also elsewhere on the board
/ADC_Out2/IN1-: C90.2, J11.3; also elsewhere on the board
/ADC_Out2/IN2+: C93.2, J11.5; also elsewhere on the board
/ADC_Out2/IN2-: C117.2, J11.6; also elsewhere on the board
/ADC_Out2/IN3+: C91.2, J11.8; also elsewhere on the board
/ADC_Out2/IN3-: C122.2, J11.9; also elsewhere on the board
/ADC_Out3/IN1+: C102.2, J12.2; also elsewhere on the board
/ADC_Out3/IN1-: C103.2, J12.3; also elsewhere on the board
/ADC_Out3/IN2+: C104.2, J12.5; also elsewhere on the board
/ADC_Out3/IN2-: C119.2, J12.6; also elsewhere on the board
/ADC_Out3/IN3+: C107.2, J12.8; also elsewhere on the board
/ADC_Out3/IN3-: C125.2, J12.9; also elsewhere on the board
/ADC_Out/IN1+: C99.2, J21.2; also elsewhere on the board
/ADC_Out/IN1-: C3.2, J21.3; also elsewhere on the board
/ADC_Out/IN2+: C4.2, J21.5; also elsewhere on the board
/ADC_Out/IN2-: C110.2, J21.6; also elsewhere on the board
/ADC_Out/IN3+: C5.2, J21.8; also elsewhere on the board
/ADC_Out/IN3-: C121.2, J21.9; also elsewhere on the board
GND: C3.1, C4.1, C5.1, C6.2, C12.2, C89.1, C90.1, C91.1, C93.1, C99.1, C101.2, C102.1, C103.1, C104.1, C107.1, C110.1, C117.1, C119.1, C121.1, C122.1, C125.1, J7.2, J7.4, J8.2, J8.4, J9.2, J9.4, J11.1, J11.4, J11.7, J11.10, J12.1, J12.4, J12.7, J12.10, J21.1, J21.4, J21.7, J21.10; also elsewhere on the board
unnamed: C6.1, J7.3, R2.1
unnamed: C12.1, J8.3, R9.1
unnamed: C101.1, J9.3, R15.1

Notes on the sheet:
小电容放在引脚处吸收线束上的共模噪声

Schematic: OLED.kicad_sch

Parts:
C95, C98, C113: 1uF; C_0603
C111, C112, C114: 4.7uF; C_0603
R36, R37: 4.7K; R_0402_NoSilk
U5: FPC_16_0.65

Connections:
+3.3V: C114.1, R36.1, R37.1, U5.5 (VBAT), U5.7 (VDD), U5.8 (BS1); also elsewhere on the board
/G474_MCU/I2C1_SCL: R36.2, U5.12 (D0); also elsewhere on the board
/G474_MCU/I2C1_SDA: R37.2, U5.13 (D1), U5.14 (D2); also elsewhere on the board
/G474_MCU/OLED_RES: U5.10 (RES); also elsewhere on the board
GND: C111.1, C112.1, C113.1, C114.2, U5.6 (VSS), U5.9 (CS), U5.11 (D/C); also elsewhere on the board
unnamed: C95.2, U5.4 (C1N)
unnamed: C95.1, U5.3 (C1P)
unnamed: C98.2, U5.2 (C2N)
unnamed: C98.1, U5.1 (C2P)
unnamed: C112.2, C113.2, U5.16 (VCC)
unnamed: C111.2, U5.15 (VCOMH)

Schematic: 5V filter.kicad_sch

Parts:
D26: 5V TVS; D_SOD-123F

Connections:
+5VA: D26.1 (A1); also elsewhere on the board
GND: D26.2 (A2); also elsewhere on the board

Parts of its further copies:
D22, D24, D25, D28: 5V TVS; D_SOD-123F

Connections of its further copies:
+5VA: D22.1 (A1), D24.1 (A1), D25.1 (A1), D28.1 (A1); also elsewhere on the board
GND: D22.2 (A2), D24.2 (A2), D25.2 (A2), D28.2 (A2); also elsewhere on the board
